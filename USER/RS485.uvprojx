# Keil uVision project RS485.uvprojx, settings and files
target RS485 (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JSRTU_V1 +hex
  AfterMake: D:\keil5\ARM\ARMCC\bin\fromelf.exe --bin --output ../OBJ/JSRTU_V1.bin  ../OBJ/JSRTU_V1.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\RS485;..\HARDWARE\MODBUS;..\HARDWARE\EC20;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\protocol;..\HARDWARE\flash;..\HARDWARE\queue;..\HARDWARE\MALLOC;..\HARDWARE\SD;..\HARDWARE\hc08;..\HARDWARE\adc;..\HARDWARE\handlewater;..\HARDWARE\SD
  memory RVCT4: ROM 0x8008000 size 0x34000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c stm32f4xx_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/LCD/: lcd.c lcd.h lcdhandle.h lcdhandle.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MODBUS/: modbus.c
    ../HARDWARE/EC20/: EC20.c
    ../HARDWARE/IWDG/: iwdg.c iwdg.h
    ../HARDWARE/protocol/: protocol.c protocol.h
    ../HARDWARE/hc08/: hc08.c hc08.h
    ../HARDWARE/flash/: flash.c flash.h
    ../HARDWARE/queue/: liuqueue.c liuqueue.h
    ../HARDWARE/SD/: sdio_sdcard.c sdio_sdcard.h sdhandle.h sdhandle.c
    ../HARDWARE/adc/: adc.h adc.c
    ../HARDWARE/handlewater/: handlewater.h handlewater.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_adc.c
    ../FWLIB/inc/: stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_rtc.h stm32f4xx_pwr.h stm32f4xx_dma.h stm32f4xx_sdio.h stm32f4xx_adc.h
